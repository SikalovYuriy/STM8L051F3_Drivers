# IAR project STM8L051F3_Drivers.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.CCIncludePath2: headers; StdPeriph_Driver
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: STM8L051F3_Drivers.srec
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group (top)
    ./: main.cpp
  group Drivers
    Drivers/: Driver_ADC.cpp Driver_EEPROM.cpp Driver_GPIO.cpp Driver_GPIO_pin.cpp Driver_Timer.cpp Driver_Timer2.cpp Driver_UART.cpp Init_GPIO.cpp Init_UART.cpp Init_UART.hpp
  group headers
    headers/: type.h
