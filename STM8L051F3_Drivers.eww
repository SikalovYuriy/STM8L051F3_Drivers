<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM8L051F3_Drivers.ewp</path>
  </project>
  <batchBuild/>
</workspace>


